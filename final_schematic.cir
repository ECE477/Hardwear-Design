.title KiCad schematic
C13 3V3 GND 0.1u
RED1 Net-_R10-Pad1_ Net-_RED1-Pad2_ LED_GPS_R
J8 Net-_J8-Pad1_ GND GPS_COAX
R10 Net-_R10-Pad1_ GND 1k
U2 3V3 NC_01 GND NC_02 Net-_RED1-Pad2_ NC_03 NC_04 GND USART_RX USART_TX Net-_J8-Pad1_ GND NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 GND NC_11 MTK3339
C18 Net-_C18-Pad1_ GND 0.1u
Re1 3V3 IMU_nRST 10k
Rf1 Net-_Rf1-Pad1_ 3V3 10k
J1 GND V_supply I2C2_SDA I2C2_SCL BB_COM_Conn_01x04_Male
D1 Net-_D1-Pad1_ 3V3 LED_HEARTBEAT_R1
D2 Net-_D2-Pad1_ DIO0 LED_TRANSMIT_G1
R1 GND Net-_D1-Pad1_ 62
R2 GND Net-_D2-Pad1_ 62
S1 V_supply 3V3 GND ON/OFF-SWITCH
SW3 Net-_C3-Pad2_ GND SW_Push_RST
C3 GND Net-_C3-Pad2_ 1u
R5 3V3 Net-_C3-Pad2_ 10k
SW1 Net-_C1-Pad2_ GND SW_Push_SESS
C1 GND Net-_C1-Pad2_ 1u
R3 3V3 Net-_C1-Pad2_ 10k
SW2 Net-_C2-Pad2_ GND SW_Push_RADIO
C2 GND Net-_C2-Pad2_ 1u
R4 3V3 Net-_C2-Pad2_ 10k
J5 GND 3V3 SPI1_MOSI SPI1_SCK DC_OLED CS_OLED OLED_SPI_Conn_01x06_Male
J6 Net-_C12-Pad1_ OLED_EN_Conn_01x01_Male
C12 Net-_C12-Pad1_ GND 1u
R9 3V3 Net-_C12-Pad1_ 10k
C15 GND 3V3 0.1u
C16 3V3 GND 0.12u
C17 3V3 GND 0.0068u
U4 NC_12 GND 3V3 Net-_Rf1-Pad1_ GND GND NC_13 NC_14 Net-_C18-Pad1_ BL_IND IMU_nRST NC_15 NC_16 IMU_INT GND GND IMU_COM3 GND I2C_SCL I2C_SDA NC_17 NC_18 NC_19 NC_20 GND NC_21 NC_22 3V3 BNO055
C14 GND 3V3 10u
C8 3V3 GND 0.1u
C9 3V3 GND 0.1u
C10 3V3 GND 0.1u
C11 3V3 GND 0.1u
C6 3V3 GND 0.1u
C7 3V3 GND 0.1u
U1 NC_23 IMU_INT NC_24 NC_25 NC_26 3V3 NC_27 NC_28 NC_29 GND 3V3 IMU_COM3 BL_IND NRST NC_30 NC_31 NC_32 NC_33 GND GND 3V3 NC_34 NC_35 NC_36 NC_37 LoRa_RST GND 3V3 CS_OLED SPI1_SCK SPI1_MISO SPI1_MOSI NC_38 NC_39 radio_btn session_btn NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 CS_LORA NC_46 NC_47 NC_48 I2C2_SCL I2C2_SDA GND 3V3 BB_CE BB_GPOUT SYSOFF NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 DC_OLED NC_62 NC_63 NC_64 NC_65 SWDIO NC_66 GND 3V3 SWCLK NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 USART_TX USART_RX NC_75 NC_76 SWO NC_77 NC_78 I2C_SCL I2C_SDA BOOT0 NC_79 NC_80 IMU_nRST NC_81 GND 3V3 STM32L476VGTx
R7 3V3 I2C_SDA 2.2k
R8 3V3 I2C_SCL 2.2k
C5 3V3 GND 0.1u
C4 3V3 GND 1u
R6 BOOT0 GND 510
LoRa_CON_Coaxial1 Net-_LoRa_CON_Coaxial1-Pad1_ GND LoRa_Conn_Coaxial
R11 Net-_C2-Pad2_ radio_btn 62
R13 Net-_C1-Pad2_ session_btn 62
R12 Net-_C3-Pad2_ NRST 62
J4 BOOT0 GND BOOT0_Conn_Male
J3 SYSOFF GND BB_ON/OFF_CONN_01x02_Male
J2 BB_CE BB_GPOUT GND BB_CTRL_Conn_01x03_Male
U3 GND SPI1_MISO SPI1_MOSI SPI1_SCK CS_LORA LoRa_RST NC_82 GND Net-_LoRa_CON_Coaxial1-Pad1_ GND NC_83 NC_84 3V3 DIO0 NC_85 NC_86 RFM95W-915S2
J7 3V3 NRST SWCLK SWDIO SWO GND Conn_01x06_Male
V1 3V3 GND 3.3
.end
